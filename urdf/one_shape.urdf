Commit message: Edit urdf

File: urdf/one_shape.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- removed link camera
- added link one_shape; visual cylinder length=0.3 radius=0.1
